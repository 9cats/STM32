<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\101Run_Hrose.ewp</path>
  </project>
  <batchBuild />
</workspace>
