# Keil uVision project 数字化语音采集回放系统.uvproj, settings and files
target 数字化语言采集回放系统 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: 数字化语言采集回放系统 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\..\.COMMON\CORE;..\..\.COMMON\FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\EXTI;..\HARDWARE\FLASH;..\HARDWARE\LCD;..\HARDWARE\TIM;..\HARDWARE\KEY;..\HARDWARE\TOUCH;..\HARDWARE\24CXX;..\HARDWARE\IIC
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_conf.h
  group HARDWARE
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/DAC/: dac.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/TIM/: timer.c
    ../HARDWARE/TOUCH/: ctiic.c ft5206.c gt9147.c ott2001a.c touch.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/IIC/: myiic.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group FWLIB
    ../../.COMMON/FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_flash.c stm32f4xx_exti.c stm32f4xx_tim.c stm32f4xx_fsmc.c stm32f4xx_syscfg.c
  group CORE
    ../../.COMMON/CORE/: startup_stm32f40_41xxx.s system_stm32f4xx.c core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h stm32f4xx.h system_stm32f4xx.h
