# Keil uVision project LED+KEY+IO.uvproj, settings and files
target LED+KEY+IO (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: LED+KEY+IO +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\..\.COMMON\CORE;..\..\.COMMON\FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\BEEP;..\HARDWARE\OUTPUT
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_conf.h
  group HARDWARE
    ../HARDWARE/LED/: led.c led.h
    ../HARDWARE/KEY/: key.c key.h
    ../HARDWARE/BEEP/: beep.c beep.h
    ../HARDWARE/OUTPUT/: output.c output.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group FWLIB
    ../../.COMMON/FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c
  group CORE
    ../../.COMMON/CORE/: startup_stm32f40_41xxx.s system_stm32f4xx.c core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h stm32f4xx.h system_stm32f4xx.h
